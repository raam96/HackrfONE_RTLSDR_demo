options:
  parameters:
    author: Lt NPH Raam
    copyright: gnu
    generate_options: qt_gui
    id: wbfm_tx
    output_language: python
    title: WBFM
  states: {}

blocks:
- name: audio_sample_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: base_freq
  id: variable_qtgui_range
  parameters:
    start: 400e6
    step: 1e3
    stop: 400.3e6
    value: 400e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX GAIN
    start: '0'
    step: '1'
    stop: '47'
    value: '10'
    widget: slider
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 50e3
    quad_rate: 48000*2
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_sample_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '6'
    gain: '1'
    interp: '6'
    samp_rate: 50e3
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: base_freq
    gain0: '20'
    if_gain0: tx_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 2e6
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"before"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 2e6
    fc: '0'
    fftsize: '512'
    grid: 'True'
    name: '"after"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '10000'
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
