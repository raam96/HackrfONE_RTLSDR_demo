options:
  parameters:
    author: Lt Raam
    generate_options: qt_gui
    id: nfbm_rx
    output_language: python
    title: NFBM Receiver
  states: {}

blocks:
- name: LPF_CUTOFF_FEQ
  id: variable_qtgui_range
  parameters:
    label: LPF_CUTOFF_FEQ
    start: 8e3
    step: 1e3
    stop: 30e3
    value: 15e3
  states: {}
- name: VOLUME
  id: variable_qtgui_range
  parameters:
    label: VOLUME
    start: '0.5'
    step: '0.1'
    stop: '2.0'
    value: '0.7'
  states: {}
- name: base_band_freq
  id: variable_qtgui_range
  parameters:
    start: 399e6
    step: 1e2
    stop: 401e6
    value: '399994800'
  states: {}
- name: input_decimation
  id: variable
  parameters:
    value: '26'
  states: {}
- name: main_sample_rate
  id: variable
  parameters:
    value: 12e3
  states: {}
- name: resampler_decimation
  id: variable_qtgui_range
  parameters:
    label: resampler_decimation
    rangeType: int
    start: '15'
    step: '1'
    stop: '30'
    value: '26'
  states: {}
- name: reveiver_gain
  id: variable_qtgui_range
  parameters:
    label: reveiver_gain
    rangeType: int
    start: '10'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: rtl_samp
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.8e6
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: VOLUME
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: LPF_CUTOFF_FEQ
    decim: '1'
    gain: '1'
    samp_rate: LPF_CUTOFF_FEQ*2
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rtl_samp
    fc: base_band_freq
    fftsize: '1024'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: main_sample_rate*2
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resampler_decimation
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '6'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: reveiver_gain
    freq0: base_band_freq
    gain0: reveiver_gain
    gain_mode0: 'False'
    if_gain0: reveiver_gain
    sample_rate: rtl_samp
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
