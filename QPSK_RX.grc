options:
  parameters:
    author: Lt Raam
    generate_options: qt_gui
    id: qpsk_rx
    output_language: python
    title: QPSK RECEIVER
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: |-
      Must know that symbols are secretly and
      automatically normalized so that
      mean(abs(symbols))==1
    const_points: symbols
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1,2,3]'
    type: calcdist
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-20e3'
    step: '1'
    stop: 20e3
    value: +12e3
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: symbols
  id: variable
  parameters:
    value: '[0.4, 0.8, 1.2, 1.6]'
  states: {state: disabled}
- name: symbols
  id: variable
  parameters:
    value: '[1,1j, -1, -1j]'
  states: {state: disabled}
- name: symbols
  id: variable
  parameters:
    comment: |-
      need diagonals to use
      Constellation Decoder
    value: '[-1-1j, -1+1j, 1+1j, 1-1j]'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '4'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Loop Bandwidth:
      2*3.14/100
    order: '4'
    w: 2*3.14/100
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*4
    type: fir_filter_ccf
    width: samp_rate
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*4
    type: fir_filter_ccf
    width: samp_rate
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Raw
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Tuned
    name: '"RECEIVED CONSTELLATION SINK WITH SIGNAL SOURCE"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Costas
    name: '"RECEIVED CONSTELLATION SINK WITH SIGNAL SOURCE AFTER COSTAS LOO"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: Receive Raw
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: Receive Tuned
    name: '"RECEIVED FREQUENCY SINK WITH SIGNAL SOURCE"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Raw Re
    label2: Receive Raw Im
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Tuned Re
    label2: Receive Tuned Im
    name: '"RECEIVED TIME SINK WITH SIGNAL SOURCE"'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive^4 Re
    label2: Receive^4 Im
    name: '"RECEIVED AFTER AGC"'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Costas Re
    label2: Receive Costas Im
    name: '"RECEIVED TIME SINK WITH SIGNAL SOURCE AFTER COSTAS LOOP"'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: '"CONSTELLATION DECODED SIGNAL"'
    size: 1024*8
    srate: samp_rate
    type: float
    ymax: '4'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_exponentiate_const_cci_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_exponentiate_const_cci_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_xx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', low_pass_filter_0, '0']
- [digital_costas_loop_cc_0, '0', low_pass_filter_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [low_pass_filter_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_const_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
