options:
  parameters:
    author: raam
    generate_options: qt_gui
    id: FSK_RX
    output_language: python
    title: FSK RX
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-20e3'
    step: '1'
    stop: 20e3
    value: '0'
  states: {}
- name: rtl_samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: rtl_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: |-
      Loop Bandwidth:
      2*3.14/100
    order: '2'
    w: 2*3.14/100
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: rtl_samp_rate
    decim: '1'
    gain: '1'
    samp_rate: rtl_samp_rate*4
    type: fir_filter_ccf
    width: rtl_samp_rate
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Raw
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Offset
    name: '"COSINE MIXED CONSTELLATION SINK BEFORE COSTAS LOOP"'
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: Receive Costas
    name: '"RECEIVED SIGNAL FREQUENCY SINK AFTER COSTAS LOOP"'
    size: '1024'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rtl_samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: Receive Raw
    name: '"RECEIVED SIGNAL FREQUENCY SINK"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rtl_samp_rate
    fc: '0'
    fftsize: 1024*8
    label1: Receive Offset
    name: '"COSINE MIXED TIME SINK BEFORE COSTAS LOOP"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Raw Re
    label2: Receive Raw Im
    name: '"RECEIVED SIGNAL TIME SINK"'
    size: 1024*8
    srate: rtl_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Offset Re
    label2: Receive Offset Im
    name: '"COSINE MIXED TIME SINK BEFORE COSTAS LOOP"'
    size: 1024*8
    srate: rtl_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Receive Costas Re
    label2: Receive Costas Im
    name: '"RECEIVED SIGNAL TIME SINK AFTER COSTAS LOOP"'
    size: 1024*8
    srate: rtl_samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rtl_samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [low_pass_filter_0, '0', digital_costas_loop_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_const_sink_x_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_const_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
