options:
  parameters:
    generate_options: qt_gui
    id: SSB_LSB_TX
    output_language: python
    title: SSB LSB TRANSMITTER
  states: {}

blocks:
- name: freq_shift
  id: variable_qtgui_range
  parameters:
    start: 10e6
    step: 1e2
    stop: 15e6
    value: 12.5e6
    widget: counter
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: GAIN
    start: '0'
    step: '1'
    stop: '47'
    value: '10'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sdr_samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: usb_freq
  id: variable_qtgui_range
  parameters:
    start: 14e6
    step: '10'
    stop: 15e6
    value: 14.15e6
    widget: slider
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_1_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: hilbert_fc_0_1
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: hilbert_fc_0_1_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: usb_freq
    gain0: '20'
    if_gain0: gain
    sample_rate: sdr_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: usb_freq
    fftsize: '1024'
    name: '"ORRIGINAL"'
    rate: '5'
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: usb_freq
    fftsize: '1024'
    name: '"CONVERTED"'
    rate: '5'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"I & Q INFO"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0_1_1, '0']
- [audio_source_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', hilbert_fc_0_1, '0']
- [band_pass_filter_0, '0', hilbert_fc_0_1_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_float_0_1, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0_1, '1', blocks_null_sink_0_0, '0']
- [blocks_complex_to_float_0_1_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_complex_to_float_0_1_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0_1_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_float_0_1_1, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0_1_1, '1', blocks_multiply_xx_0_0, '1']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_float_to_complex_0, '1']
- [hilbert_fc_0_1, '0', blocks_complex_to_float_0_1, '0']
- [hilbert_fc_0_1_0, '0', blocks_complex_to_float_0_1_0, '0']

metadata:
  file_format: 1
