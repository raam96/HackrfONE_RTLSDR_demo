options:
  parameters:
    author: RAAM
    generate_options: qt_gui
    id: wfm_rx
    output_language: python
    title: WFM RECEIVER
  states: {}

blocks:
- name: LPF_decimation
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '10'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: '400000000'
    step: '10'
    stop: '400100000'
    value: '400000010'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(samp_rate/LPF_decimation/48e3)
    quad_rate: samp_rate/LPF_decimation
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: LPF_decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tune
    fftsize: 2**12
    label1: Raw
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/LPF_decimation
    fc: '0'
    fftsize: 2**12
    label1: Low Passed
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 48e3
    fc: '0'
    fftsize: 2**12
    label1: Audio
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Raw Re
    label2: Raw Im
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: Low Passed Re
    label2: Low Passed Im
    size: '1024'
    srate: samp_rate/LPF_decimation
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: Audio
    size: '1024'
    srate: 48e3
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: tune
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_2, '0']
- [low_pass_filter_1, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_1, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
